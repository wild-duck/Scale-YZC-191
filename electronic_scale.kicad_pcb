# Repository wild-duck/Scale-YZC-191

File README.md:

一个小型电子秤，基于YZC-191传感器，此项目仅包含电路文件

## KiCad design electronic_scale.kicad_pcb

Notes on the sheet:
按键按下低电平
拉低关机

Parts:
C1: 10u; C_0603_1608Metric
C2, C3: 22u; C_0603_1608Metric
D1, D2: CUS10S30; D_SOD-323
D3: BAT54-05; SOT-23
D4: LED_Dual_AAKK; SMD-1615
H1, H2, H3, H4: MountingHole_Pad_MP; MountingHole_3.2mm_M3_DIN965_Pad
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: Conn_01x02_MountingPin; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal
L2: L; L_0603_1608Metric
Q1, Q2: Si2305CDS; SOT-23
Q3: SS8050; SOT-23
R1, R2: 5k1; R_0603_1608Metric
R5, R11: 1k; R_0603_1608Metric
R6, R8, R9, R10, R12: 10k; R_0603_1608Metric
R7: 4k7; R_0603_1608Metric
SW1: SW_Push; SW_TH_Tactile_Omron_B3F-106x
U1: HT7533-1; SOT-89-3
U2: TP4056-42-ESOP8; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias

Connections:
+3.3V: C3.1, L2.2; also elsewhere on the board
+3.3VA: C2.1, L2.1, U1.3 (VOUT); also elsewhere on the board
/core&adc/PB10: R11.2; also elsewhere on the board
/core&adc/PB11: R8.1; also elsewhere on the board
/core&adc/USB_DM: J1.A7 (D-), J1.B7 (D-); also elsewhere on the board
/core&adc/USB_DP: J1.A6 (D+), J1.B6 (D+); also elsewhere on the board
/power/GLED: D4.4 (K2), U2.6 (~STDBY)
/power/RLED: D4.3 (K1), U2.7 (~CHRG)
GND: C1.2, C2.2, C3.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.2, Q3.2 (E), R1.2, R2.2, R5.2, R6.2, R12.2, SW1.1, U1.1 (GND), U2.1 (TEMP), U2.3 (GND), U2.9 (EPAD); also elsewhere on the board
unnamed: D1.1 (K), D2.1 (K), Q1.2 (S), Q2.2 (S), R10.1
unnamed: D2.2 (A), J2.1, Q1.3 (D), U2.5 (BAT)
unnamed: D3.2 (A1), R8.2
unnamed: D3.1 (A2), Q2.1 (G), Q3.3 (C), R10.2
unnamed: D3.3 (K), SW1.2
unnamed: D4.1 (A1), D4.2 (A2), R9.1
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: Q1.1 (G), R7.2
unnamed: Q3.1 (B), R11.1, R12.1
unnamed: R5.1, U2.2 (PROG)
VCC: C1.1, Q2.3 (D), U1.2 (VIN); also elsewhere on the board
VIN: D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R6.1, R7.1, R9.2, U2.4 (V_{CC}), U2.8 (CE)

Parts:
C4, C5: 22p; C_0603_1608Metric
C6, C7, C8, C9, C10, C11, C12, C13: 100n; C_0603_1608Metric
J3: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
J4: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x04_Pin; PinHeader_1x04_P2.00mm_Vertical
Q4: SS8550; SOT-23
R3, R4, R13, R17: 10k; R_0603_1608Metric
R14: 1k; R_0603_1608Metric
R15: 100k; R_0603_1608Metric
R16: 4.7k; R_0603_1608Metric
SW2, SW3: SW_Push; SW_TH_Tactile_Omron_B3F-106x
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
U4: HX711; SOIC-16_3.9x9.9mm_P1.27mm
X1: 8M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, J3.2, J4.1, R3.1, R4.1, R17.2, U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U4.1 (VSUP), U4.16 (DVDD); also elsewhere on the board
+3.3VA: Q4.2 (E); also elsewhere on the board
/core&adc/DOUT: U3.14 (PA4), U4.12 (DOUT)
/core&adc/I2C_SCL: J3.3, R4.2, U3.45 (I2C1_SCL)
/core&adc/I2C_SDA: J3.4, R3.2, U3.46 (I2C1_SDA)
/core&adc/KEY1: SW2.2, U3.39 (PB3)
/core&adc/KEY2: SW3.2, U3.40 (PB4)
/core&adc/PB10: U3.21 (PB10); also elsewhere on the board
/core&adc/PB11: U3.22 (PB11); also elsewhere on the board
/core&adc/PD_SCK: U3.15 (PA5), U4.11 (PD_SCK)
/core&adc/RATE: R17.1, U3.13 (PA3), U4.15 (RATE)
/core&adc/USB_DM: U3.32 (USB_DM); also elsewhere on the board
/core&adc/USB_DP: U3.33 (USB_DP); also elsewhere on the board
GND: C4.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J3.1, J4.4, J5.4, R13.1, R15.2, SW2.1, SW3.1, U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.4 (VFB), U4.5 (AGND), U4.14 (XI), X1.2, X1.4; also elsewhere on the board
unnamed: J4.2, U3.34 (SYS_JTMS-SWDIO)
unnamed: J4.3, U3.37 (SYS_JTCK-SWCLK)
unnamed: J5.1, Q4.3 (C), U4.3 (AVDD)
unnamed: J5.2, U4.7 (INA-)
unnamed: J5.3, U4.8 (INA+)
unnamed: Q4.1 (B), R16.1
unnamed: R13.2, U3.44 (BOOT0)
unnamed: C6.2, U3.7 (NRST)
unnamed: C4.2, U3.5 (RCC_OSC_IN), X1.1
unnamed: C5.2, U3.6 (RCC_OSC_OUT), X1.3
unnamed: R16.2, U4.2 (BASE)
unnamed: R14.2, R15.1, U4.9 (INB-)
unnamed: C7.1, U4.6 (VBG)
VCC: R14.1, U4.10 (INB+); also elsewhere on the board

Board: 2 copper layers, 53.0 x 49.0 mm, 56 parts (0 on the bottom side), 42 nets.

## Commit log

2026-04-21 更正电源开关电路的原理错误
